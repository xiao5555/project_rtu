# Keil uVision project RTU_4G.uvprojx, settings and files
target RTU_4G (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: RTU_4G +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Core/Inc;    ../Drivers/STM32L4xx_HAL_Driver/Inc;    ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;    ../Drivers/CMSIS/Include;    .\HardWare;    .\SysInfo;    .\Tools;    .\UI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Core/Src/: main.c gpio.c usart.c tim.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Tools
    ./Tools/Memory/: memory.c
    ./Tools/PrivateList/: PrivateList.c
    ./Tools/PrivateMsg/: PrivateMsg.c
    ./Tools/PrivateTimer/: PrivateTimer.c
  group UI/APP
    ./UI/Application/GUI/: gui.c
    ./UI/Application/App/: Main_View.c Config_View.c ManualSet_View.c SysRest_View.c SetRainMain_VIEW.c SetRainValue_VIEW.c SetWaterMain_VIEW.c SetWaterValue_VIEW.c Hint_View.c UploadManualData_View.c ParameterSet_View.c InstallTest_View.c ClearHistorical_View.c VersionView_View.c
  group UI/MIDDLE
    ./UI/Middle/Src/: config.c event.c middle.c InputBox.c
  group UI/LIB
    ./UI/Lib/Font/: Font.c
    ./UI/Lib/PictureComponent/: PictureComponent.c
  group UI/DRIVER
    ./UI/Driver/: LcdApi.c
  group HardWare
    ./HardWare/Src/: 24cxx.c key.c LcdDriver.c mesh.c modbus.c sim800.c usartProcess.c w25qxx.c
  group SysInfo
    ./SysInfo/Src/: Attribute.c AttributeInterface.c SysInfo.c
software components: CMSIS:CORE 4.3.0
